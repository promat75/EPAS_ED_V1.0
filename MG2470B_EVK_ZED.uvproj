# Keil uVision project MG2470B_EVK_ZED.uvproj, settings and files
target EndDevice (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_INS +hex
  AfterMake: .\Rename_HexFile.bat
  c flags: Optimize=9
  c define: __DEBUG,__INTERNAL_MODE
  c include: .\Platform\Include\;.\Platform\hal\;.\Sample\Include\;.\Sample\Utility\;.\Sample\EVB
  group Platform/Include
    ./Platform/Include/: Include_MG2470.h MG2470.h MG2470_LIB.h rpmemcpy.h
  group Platform/asm
    ./Platform/asm/: L51_BANK_RP_MG2470.a51 rpmemcpy.a51 STARTUP_BANK_RP_MG2470.a51
  group Platform/hal
    ./Platform/hal/: ADC.c ADC.h CLOCK.c CLOCK.h EXTI.c EXTI.h FLASH.c FLASH.h GPIO.c GPIO.h GPIOINT.c GPIOINT.h HMAC.c HMAC.h i2c.h i2c.c PHY.c PHY.h POWER.c POWER.h PWM.c PWM.h SECURITY.c SECURITY.h SPI.c SPI.h TIMER.c TIMER.h UART.c UART.h WDT.c WDT.h HIB.c HIB.h irtx_NEC.c irtx_NEC.h
  group Platform/Library
    ./Platform/Library/: MG2470_LIB_V25.LIB
  group Utility
    ./Sample/Utility/: UTIL_APP.c UTIL_APP.h UTIL_SYS.c UTIL_SYS.h
  group Application
    ./Sample/EVB/: isr.c Option_EVB.h ib_main_sen.c ib_sensor.c ib_packet.c ib_uart.c ib_zigbee.c ib_ir_sen.c ib_temp_sen.c
  group Include
    ./Sample/Include/: IEEE_802_15_4.h
target EndDevice_Zener (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_INS +hex
  AfterMake: .\DelEndCode.bat
  AfterMake: D:\Projects\SmartSensor\Source\EndDevice\SSDAE_V01.5\Rename_ZNR_HexFile.bat
  c flags: Optimize=9
  c define: __DEBUG,__INTERNAL_MODE,__ZENER_BOARD
  c include: as above
target EndDevice_Ext (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_EXT +hex
  AfterMake: .\DelEndCode.bat
  c flags: Optimize=9
  c define: __DEBUG
  c include: as above
target EndDevice_Note (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_INS +hex
  AfterMake: .\DelEndCode.bat
  AfterMake: .\CopyEndInCode.bat
  c flags: Optimize=9
  c define: __DEBUG,__INTERNAL_MODE
  c include: as above
target EndDevice_NoteExt (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_Ext +hex
  AfterMake: .\DelEndCode.bat
  AfterMake: .\CopyEndExtCode.bat
  c flags: Optimize=9
  c define: __DEBUG,__INTERNAL_MODE
  c include: as above
target Old_EndDevice (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: MG2470B_SSM_ZED_INS_Old +hex
  AfterMake: F:\Projects\SmartSensor\Source\EndDevice\SSDAE_V01.02\DelEndCode.bat
  c flags: Optimize=9
  c define: __DEBUG,__INTERNAL_MODE,__OLD_BOARD
  c include: as above
